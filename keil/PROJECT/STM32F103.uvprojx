# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32_USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\USART;..\HARDWARE\IO_SPI;..\HARDWARE\IO_IIC;..\HARDWARE\W25QXX;..\HARDWARE\24CXX;..\HARDWARE\LCD_BSP;..\HARDWARE\LCD_API;..\HARDWARE\KEY;..\HARDWARE\EZIO;..\HARDWARE\TOUCH;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\TIMER;..\MODULES\FATFS;..\MODULES\page;..\MODULES\UI;..\HARDWARE\SDIO;..\MODULES\FATFS\src;..\MODULES\FATFS\src\option;..\HARDWARE\Sensor;..\MODULES\motor;..\MODULES\map
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_USER
    ../STM32_USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/USART/: usart.c usart.h
    ../HARDWARE/IO_SPI/: iospi.c iospi.h
    ../HARDWARE/W25QXX/: w25qxx.c w25qxx.h
    ../HARDWARE/24CXX/: 24cxx.c 24cxx.h
    ../HARDWARE/IO_IIC/: ioiic.c ioiic.h
    ../HARDWARE/LCD_BSP/: LcdBsp.c LcdBsp.h
    ../HARDWARE/LCD_API/: LcdApi.c LcdApi.h HanziFont.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/EZIO/: ezio.c ezio.h
    ../HARDWARE/TOUCH/: touch.c touch.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/TIMER/: timer.h timer.c
    ../HARDWARE/DAC/: dac.h dac.c
    ../HARDWARE/SDIO/: sdio_sdcard.c sdio_sdcard.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/Sensor/: sensor.c sensor.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group MODULES
    ../MODULES/page/: page.c page.h
    ../MODULES/UI/: UI.c UI.h
    ../MODULES/FATFS/src/: ff.h ff.c diskio.c diskio.h ffconf.h integer.h
    ../MODULES/FATFS/src/option/: syscall.c unicode.c
    ../MODULES/motor/: motor.c motor.h
    ../MODULES/map/: map.c map.h
